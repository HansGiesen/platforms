SRC_URI += "file://bsp.cfg \
            file://user_2020-06-22-10-19-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
