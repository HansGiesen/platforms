SRC_URI += "file://user_2020-05-13-11-32-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

