SRC_URI += "file://user_2020-05-13-14-08-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

